# Keil uVision project iSO-STM32.uvproj, settings and files
target 指令发生器 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 流水灯 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\TIM4_PWM;..\..\User\MODBUS;..\..\User\ADC3;..\..\User\Communication;..\..\User\TIM7;..\..\User\TIM5_PulseWidth;..\..\User\SignalChannelSwitch;..\..\User\Delay;..\..\User\VoltageMeasure;..\..\User\ToggleSwitchAndAlarm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h includes.h
    ../../User/TIM4_PWM/: TIM4_PWM.c
    ../../User/MODBUS/: CRC16.c MODBUS.c TIME6.c USART.c RS485.c
    ../../User/ADC3/: ADC3.c TIME3.c
    ../../User/Communication/: Communication.c
    ../../User/TIM7/: TIME7.c
    ../../User/TIM5_PulseWidth/: TIM5_PulseWidth.c
    ../../User/SignalChannelSwitch/: SignalChannelSwitch.c
    ../../User/Delay/: Delay.c
    ../../User/VoltageMeasure/: VoltageMeasure.c
    ../../User/ToggleSwitchAndAlarm/: ToggleSwitchAndAlarm.c
  group DOC
    ../../Doc/: readme.h
